# Repository AGH-Logic-Unit/maluch (continued)

## KiCad design PCB/Kicad/memory_controller/memory_controller.kicad_pcb (continued)

Schematic: RegAddr.kicad_sch, REG ADDR

Parts:
C11, C12: 100nF; C_0402_1005Metric
Dr0, Dr1, Dr2, Dr3, Dr4, Dr5, Dr6, Dr7, Dr8, Dr9, Dr10, Dr11, Dr12, Dr13, Dr14, Dr15: red; LED_0603_1608Metric
Rr0, Rr1, Rr2, Rr3, Rr4, Rr5, Rr6, Rr7, Rr8, Rr9, Rr10, Rr11, Rr12, Rr13, Rr14, Rr15: 680; R_0402_1005Metric
U11, U12: 74377; SSOP-20_5.3x7.2mm_P0.65mm

Connections:
/CLK: U11.11 (CP), U12.11 (CP); also elsewhere on the board
/GPU_ADDR0: Dr0.2 (A), U11.2 (Q0); also elsewhere on the board
/GPU_ADDR1: Dr1.2 (A), U11.5 (Q1); also elsewhere on the board
/GPU_ADDR2: Dr2.2 (A), U11.6 (Q2); also elsewhere on the board
/GPU_ADDR3: Dr3.2 (A), U11.9 (Q3); also elsewhere on the board
/GPU_ADDR4: Dr4.2 (A), U11.12 (Q4); also elsewhere on the board
/GPU_ADDR5: Dr5.2 (A), U11.15 (Q5); also elsewhere on the board
/GPU_ADDR6: Dr6.2 (A), U11.16 (Q6); also elsewhere on the board
/GPU_ADDR7: Dr7.2 (A), U11.19 (Q7); also elsewhere on the board
/GPU_ADDR8: Dr8.2 (A), U12.2 (Q0); also elsewhere on the board
/GPU_ADDR9: Dr9.2 (A), U12.5 (Q1); also elsewhere on the board
/GPU_ADDR10: Dr10.2 (A), U12.6 (Q2); also elsewhere on the board
/GPU_ADDR11: Dr11.2 (A), U12.9 (Q3); also elsewhere on the board
/GPU_ADDR12: Dr12.2 (A), U12.12 (Q4); also elsewhere on the board
/GPU_ADDR13: Dr13.2 (A), U12.15 (Q5); also elsewhere on the board
/GPU_ADDR14: Dr14.2 (A), U12.16 (Q6); also elsewhere on the board
/GPU_ADDR15: Dr15.2 (A), U12.19 (Q7); also elsewhere on the board
/RegAddr/DATA_IN0: U11.3 (D0); also elsewhere on the board
/RegAddr/DATA_IN1: U11.4 (D1); also elsewhere on the board
/RegAddr/DATA_IN2: U11.7 (D2); also elsewhere on the board
/RegAddr/DATA_IN3: U11.8 (D3); also elsewhere on the board
/RegAddr/DATA_IN4: U11.13 (D4); also elsewhere on the board
/RegAddr/DATA_IN5: U11.14 (D5); also elsewhere on the board
/RegAddr/DATA_IN6: U11.17 (D6); also elsewhere on the board
/RegAddr/DATA_IN7: U11.18 (D7); also elsewhere on the board
/RegAddr/DATA_IN8: U12.3 (D0); also elsewhere on the board
/RegAddr/DATA_IN9: U12.4 (D1); also elsewhere on the board
/RegAddr/DATA_IN10: U12.7 (D2); also elsewhere on the board
/RegAddr/DATA_IN11: U12.8 (D3); also elsewhere on the board
/RegAddr/DATA_IN12: U12.13 (D4); also elsewhere on the board
/RegAddr/DATA_IN13: U12.14 (D5); also elsewhere on the board
/RegAddr/DATA_IN14: U12.17 (D6); also elsewhere on the board
/RegAddr/DATA_IN15: U12.18 (D7); also elsewhere on the board
/RegAddr/~CLK_en: U11.1 (~E), U12.1 (~E); also elsewhere on the board
GND: C11.1, C12.1, Rr0.2, Rr1.2, Rr2.2, Rr3.2, Rr4.2, Rr5.2, Rr6.2, Rr7.2, Rr8.2, Rr9.2, Rr10.2, Rr11.2, Rr12.2, Rr13.2, Rr14.2, Rr15.2, U11.10 (GND), U12.10 (GND); also elsewhere on the board
unnamed: Dr0.1 (K), Rr0.1
unnamed: Dr1.1 (K), Rr1.1
unnamed: Dr2.1 (K), Rr2.1
unnamed: Dr3.1 (K), Rr3.1
unnamed: Dr4.1 (K), Rr4.1
unnamed: Dr5.1 (K), Rr5.1
unnamed: Dr6.1 (K), Rr6.1
unnamed: Dr7.1 (K), Rr7.1
unnamed: Dr8.1 (K), Rr8.1
unnamed: Dr9.1 (K), Rr9.1
unnamed: Dr10.1 (K), Rr10.1
unnamed: Dr11.1 (K), Rr11.1
unnamed: Dr12.1 (K), Rr12.1
unnamed: Dr13.1 (K), Rr13.1
unnamed: Dr14.1 (K), Rr14.1
unnamed: Dr15.1 (K), Rr15.1
VCC: C11.2, C12.2, U11.20 (VCC), U12.20 (VCC); also elsewhere on the board

Schematic: memory_logic.kicad_sch, MEMORY LOGIC

Parts:
C19, C20: 100nF; C_0402_1005Metric
U19: 7408; SO-14_3.9x8.65mm_P1.27mm
U20: 7404; SO-14_3.9x8.65mm_P1.27mm

Connections:
/CLK: U19.4 (2A), U20.13 (6A); also elsewhere on the board
/GPU_ADDR15: U19.12 (4A), U20.3 (2A); also elsewhere on the board
/WRITE_ENABLE: U19.13 (4B); also elsewhere on the board
/~OE_MUX_n: U20.4 (2Y); also elsewhere on the board
/~WE_mem: U20.6 (3Y); also elsewhere on the board
GND: C19.1, C20.1, U19.7 (GND), U20.7 (GND); also elsewhere on the board
unnamed: U19.5 (2B), U20.8 (4Y)
unnamed: U19.6 (2Y), U19.9 (3A)
unnamed: U19.10 (3B), U19.11 (4Y)
unnamed: U19.8 (3Y), U20.5 (3A)
unnamed: U20.9 (4A), U20.10 (5Y)
unnamed: U20.11 (5A), U20.12 (6Y)
VCC: C19.2, C20.2, U19.1 (1A), U19.2 (1B), U19.14 (VCC), U20.1 (1A), U20.14 (VCC); also elsewhere on the board

Board: 6 copper layers, 116 parts (0 on the bottom side), 168 nets, no tracks yet.
