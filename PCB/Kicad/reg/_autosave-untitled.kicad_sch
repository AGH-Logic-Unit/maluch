File: PCB/Kicad/reg/_autosave-untitled.kicad_sch (KiCad schematic)
At the start: 4 parts, among them U7 74HC245, U8 74HC245

Commit message: VCC
Connections:
- net +5V renamed VCC
